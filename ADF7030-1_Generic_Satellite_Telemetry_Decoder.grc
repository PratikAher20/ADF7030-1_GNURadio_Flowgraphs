options:
  parameters:
    author: Pratik Aher
    generate_options: qt_gui
    id: prac_adf
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: re_samp_rate
  id: variable
  parameters:
    comment: Sample Rate after FM Demodulation
    value: 48e03
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      The file to be played back should 
      be recorded at 1.8e06 of sample rate
    value: 1.8e6
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      This block is actually responsible for separating
       out the bits from two different frequencies.
    gain: '10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: |-
      Translating the signal recorded at an offset of 
      100KHz by the SDR to avoid the DC spike.
    freq: '-100e03'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"sync_word"'
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.125'
    comment: |-
      The value of the packet_len key is 
      8 times the original packet length.
      So multiplying with 1/8 to the packet_len
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    comment: |-
      Variable Length Packer Tagger gives
      output in unpacked form.
      For ex. 0x05 will be output as
      00 00 00 00 00 01 00 01
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pratik/Documents/GnuRadio_Flowgraphs/PiLOT_G2_FG/3_1000ms_RTM
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: Converts NRZ floats to binary 0s and 1s
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"01010101010101010101010101010101010101010011010001110101"'
    tagname: sync_word
    threshold: '0'
    type: byte
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Ensure that fc > 2*Baud_Rate
    cutoff_freq: 19.2e03
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e03
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      One cannot use the CRC checker 
      appended by the ADF7030-1 transceiver
      as the length byte is omitted from the stream
      by the Variable Packet length tagger.

      So the designer should include a CRC checker
      within the Payload Packet, which will be 
      checked inside the Ground Station Software
      like COSMOS using CRC Packet Protocol
    note: For this Flow
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      Can be used for the packet having 
      fixed length of data. The CRC checking
       will be done within GNU RADIO using
        CRC Check Block.

      No need to add the CRC checking 
      within the Payload Packet.
    note: For this Flow
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: |-
      Gives out the length of the 
      packet having length is 
      equal to the value of packet_len key
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/40
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '30000'
    srate: 9.6e03
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      No need to carry huge chunk of data after 
      Low pass filtering  the spectrum.
    decim: int(samp_rate)
    interp: int(re_samp_rate)
    type: ccc
  states: {}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    comment: |-
      Always Use CRC Block from gr_satellite OOT.
      The CRC Block from GnuRadio has a slight bug in it.
    discard_crc: 'True'
    final_xor: '0xFFFF'
    initial_value: '0x0000'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x3D65'
    result_reflected: 'False'
  states: {state: disabled}
- name: satellites_crc_check_0_0
  id: satellites_crc_check
  parameters:
    comment: |-
      Always Use CRC Block from gr_satellite OOT.
      The CRC Block from GnuRadio has a slight bug in it.

      Use the last two bytes of CCSDS Packet as the CRC Check
      value with any polynomial
    discard_crc: 'True'
    final_xor: '0xFFFF'
    initial_value: '0x0000'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x3D65'
    result_reflected: 'False'
  states: {}
- name: satellites_fsk_demodulator_1
  id: satellites_fsk_demodulator
  parameters:
    baudrate: 9.6e03
    comment: |-
      This block recovers the clock from the data
      and gives out the data in NRZ format
    samp_rate: int(re_samp_rate)
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    comment: |-
      Using the Preamble = 0x55 and the Sync Word = 0x3475 
      to sync the packet and then create PDU out of it.
      One needs to mention the length of the packet in the arguments
      to correctly calculate the CRC embedded by the ADF7030-1 transceiver.
    packlen: '4'
    sync: '"01010101010101010101010101010101010101010011010001110101"'
    threshold: '0'
  states: {state: disabled}
- name: satellites_varlen_packet_tagger_0
  id: satellites_varlen_packet_tagger
  parameters:
    comment: |-
      This block can be use to get the packet length
      from the first byte and then use that length value 
      within the tag having key as "packet_len".
      This block removes the length byte after tagging it.
    endianness: gr.GR_MSB_FIRST
    length_field_size: '8'
    mtu: 255*8
    packetlen_tag: packet_len
    syncword_tag: sync_word
    use_golay: 'False'
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', satellites_fsk_demodulator_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_varlen_packet_tagger_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_crc_check_0_0, in]
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_1, '0']
- [satellites_crc_check_0, fail, blocks_message_debug_0, print]
- [satellites_crc_check_0, ok, blocks_message_debug_0, print]
- [satellites_crc_check_0_0, ok, blocks_message_debug_0, print]
- [satellites_fsk_demodulator_1, '0', digital_binary_slicer_fb_0, '0']
- [satellites_fsk_demodulator_1, '0', qtgui_time_sink_x_1_0, '0']
- [satellites_sync_to_pdu_packed_0, out, satellites_crc_check_0, in]
- [satellites_varlen_packet_tagger_0, '0', blocks_tag_debug_0_0, '0']
- [satellites_varlen_packet_tagger_0, '0', blocks_unpacked_to_packed_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
