options:
  parameters:
    author: Pratik Aher
    generate_options: qt_gui
    id: tx_pkt_adf
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: re_samp_rate
  id: variable
  parameters:
    value: 48e03
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 9.6e03
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.8e06
  states: {state: disabled}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      This block is actually responsible for separating
       out the bits from two different frequencies.
    gain: '10'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pratik/Documents/GnuRadio_Flowgraphs/PiLOT_G2_FG/3_RTM_10sec_Delay.wav
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/pratik/Documents/GnuRadio_Flowgraphs/PiLOT_G2_FG/2_RTM_TX_Raw_Rec.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters: {}
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    filter: '"sync_word"'
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"packet_len"'
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: '0.125'
    lengthtagname: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 9.6e03
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: (0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x34, 0x75, 0x03, 0x05, 0x01, 0x02, 0x20)+(0,)*100000
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/pratik/Documents/GnuRadio_Flowgraphs/PiLOT_G2_FG/2_RTM_with_1sec_delay
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(1.92e06)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pratik/Documents/GnuRadio_Flowgraphs/PiLOT_G2_FG/rec_by_tx
    nchan: '2'
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/pratik/Documents/GnuRadio_Flowgraphs/PiLOT_G2_FG/2_RTM_with_1sec_delay
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: Converts NRZ floats to binary 0s and 1s
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '"01010101010101010101010101010101010101010011010001110101"'
    tagname: sync_word
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '10'
    sensitivity: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 48e03
    decim: '1'
    gain: '1'
    samp_rate: 96e03
    type: fir_filter_ccf
    width: 1.5e03
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: Ensure that fc > 2*Baud_Rate
    cutoff_freq: 19.2e03
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e03
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 19.2e03
    decim: '1'
    gain: '1'
    samp_rate: 1.92e06
    type: fir_filter_ccf
    width: 48e03
    win: window.WIN_HAMMING
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 576e03
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 576e03
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/40
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    size: '30000'
    srate: 9.6e03
    type: float
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(96e03)
    interp: int(1.92e06)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      No need to carry huge chunk of data after 
      Low pass filtering  the spectrum.
    decim: int(1.92e06)
    interp: int(re_samp_rate)
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: int(96e03)
    interp: int(48e03)
    type: ccc
  states: {state: disabled}
- name: satellites_crc_check_0
  id: satellites_crc_check
  parameters:
    comment: |-
      Always Use CRC Block from gr_satellite OOT.
      The CRC Block from GnuRadio has a slight bug in it.
    discard_crc: 'True'
    final_xor: '0xFFFF'
    initial_value: '0x0000'
    input_reflected: 'False'
    num_bits: '16'
    poly: '0x3D65'
    result_reflected: 'False'
  states: {state: disabled}
- name: satellites_fsk_demodulator_1
  id: satellites_fsk_demodulator
  parameters:
    baudrate: 9.6e03
    comment: |-
      This block recovers the clock from the data
      and gives out the data in NRZ format
    samp_rate: int(re_samp_rate)
    subaudio: 'False'
  states: {}
- name: satellites_sync_to_pdu_packed_0
  id: satellites_sync_to_pdu_packed
  parameters:
    comment: |-
      Using the Preamble = 0x55 and the Sync Word = 0x3475 
      to sync the packet and then create PDU out of it.
    packlen: '8'
    sync: '"01010101010101010101010101010101010101010011010001110101"'
    threshold: '0'
  states: {state: disabled}
- name: satellites_sync_to_pdu_packed_1
  id: satellites_sync_to_pdu_packed
  parameters:
    packlen: '16'
    sync: '"01010101010101010101010101010101010101010011010001110101"'
    threshold: '0'
  states: {state: disabled}
- name: satellites_varlen_packet_tagger_0
  id: satellites_varlen_packet_tagger
  parameters:
    endianness: gr.GR_MSB_FIRST
    length_field_size: '8'
    mtu: 255*8
    packetlen_tag: packet_len
    syncword_tag: sync_word
    use_golay: 'False'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: data_1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: data_1
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', satellites_fsk_demodulator_1, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_file_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_complex_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_throttle_0, '0', digital_gfsk_mod_0, '0']
- [blocks_throttle_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_tagged_stream_multiply_length_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_wavfile_source_0_0, '1', blocks_float_to_complex_0_0, '1']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_packed_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', satellites_varlen_packet_tagger_0, '0']
- [digital_gfsk_mod_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_1, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_1, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_1, '0', blocks_file_sink_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_1, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_1, '0', virtual_sink_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_0_0, '0', analog_quadrature_demod_cf_1, '0']
- [rational_resampler_xxx_0_1, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_0_1, '0', virtual_sink_0, '0']
- [satellites_crc_check_0, ok, blocks_message_debug_0, print]
- [satellites_fsk_demodulator_1, '0', digital_binary_slicer_fb_0, '0']
- [satellites_fsk_demodulator_1, '0', qtgui_time_sink_x_1_0, '0']
- [satellites_sync_to_pdu_packed_0, out, blocks_message_debug_0, print]
- [satellites_sync_to_pdu_packed_1, out, blocks_message_debug_0, print]
- [satellites_varlen_packet_tagger_0, '0', blocks_tag_debug_0_0, '0']
- [satellites_varlen_packet_tagger_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [virtual_source_0, '0', analog_quadrature_demod_cf_1, '0']
- [virtual_source_0_0, '0', rational_resampler_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
